ORG 0H
LJMP MAIN

ORG 100H
MAIN:
CALL QUANT
HERE: SJMP HERE

ORG 130H
QUANT:
MOV R0,#60H
MOV R1,#70H
FLIP:
MOV A, @R0 
SUBB A, #10 
JNC LEVEL1 
MOV @R1, #5H 
SJMP NEXT


LEVEL1:
MOV A,@R0
SUBB A, #14H 
JNC LEVEL2 
MOV @R1, #0FH
SJMP NEXT 

LEVEL2:
MOV A,@R0
SUBB A, #1EH 
JNC LEVEL3 
MOV @R1, #19H
SJMP NEXT 

LEVEL3:
MOV  @R1, #23H 

NEXT:
INC R0 
INC R1 
CJNE R0,#68H,FLIP

RET
END
