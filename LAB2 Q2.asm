ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL DET
HERE: SJMP HERE
ORG 130H
// *****************
DET:
MOV A,60H
MOV B,63H
MUL AB
MOV 64H,B
MOV 65H,A
MOV A,61H
MOV B,62H
MUL AB
MOV 66H,B
MOV 67H,A
MOV A,65H
SUBB A,67H

MOV 70H,A
MOV A,64H
SUBB A,66H


MOV 71H,A


RET
END
